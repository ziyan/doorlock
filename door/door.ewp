# IAR project door.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1111.i51
  ICC8051.CCDefines: chip=1111
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: include\
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1111.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group driver
    driver/: adc.c aes.c buzzer.c clock.c crc.c flash.c idle.c ir.c ports.c prng.c radio.c servo.c timer.c
  group include
    include/: project.h
  group include/driver
    include/driver/: adc.h aes.h buzzer.h clock.h crc.h flash.h idle.h ir.h ports.h prng.h radio.h servo.h timer.h
  group include/hal
    include/hal/: hal_cc8051.h hal_defs.h hal_types.h ioCCxx10_bitdef.h
  group include/logic
    include/logic/: auth.h db.h door.h lock.h mode.h packet.h
  group logic
    logic/: auth.c db.c door.c lock.c mode.c
